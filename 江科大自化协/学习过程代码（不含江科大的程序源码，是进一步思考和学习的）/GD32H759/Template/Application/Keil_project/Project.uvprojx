# Keil uVision project Project.uvprojx, settings and files
target GD32H7xx (ARM-ADS)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32H7XX
  c include: ..\..\Startup;..\..\Peripherals;..\..\Application;..\..\System;..\..\Hardware;..\..\CMSIS;..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../: gd32h7xx_it.c gd32h7xx_it.h gd32h7xx_libopt.h main.c main.h
  group CMSIS
    ../../CMSIS/: gd32h7xx.h system_gd32h7xx.c system_gd32h7xx.h
  group Peripherals
    ../../Peripherals/: gd32h7xx_adc.c gd32h7xx_adc.h gd32h7xx_axiim.h gd32h7xx_can.c gd32h7xx_can.h gd32h7xx_cau.c gd32h7xx_cau.h gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cmp.h gd32h7xx_cpdm.c gd32h7xx_cpdm.h gd32h7xx_crc.c gd32h7xx_crc.h gd32h7xx_ctc.c gd32h7xx_ctc.h gd32h7xx_dac.c gd32h7xx_dac.h gd32h7xx_dbg.c gd32h7xx_dbg.h gd32h7xx_dci.c gd32h7xx_dci.h gd32h7xx_dma.c gd32h7xx_dma.h gd32h7xx_edout.c gd32h7xx_edout.h gd32h7xx_efuse.c gd32h7xx_efuse.h gd32h7xx_enet.c gd32h7xx_enet.h gd32h7xx_exmc.c gd32h7xx_exmc.h gd32h7xx_exti.c gd32h7xx_exti.h gd32h7xx_fac.c gd32h7xx_fac.h gd32h7xx_fmc.c gd32h7xx_fmc.h gd32h7xx_fwdgt.c gd32h7xx_fwdgt.h gd32h7xx_gpio.c gd32h7xx_gpio.h gd32h7xx_hau.c gd32h7xx_hau.h gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hpdf.h gd32h7xx_hwsem.c gd32h7xx_hwsem.h gd32h7xx_i2c.c gd32h7xx_i2c.h gd32h7xx_ipa.c gd32h7xx_ipa.h gd32h7xx_lpdts.c gd32h7xx_lpdts.h gd32h7xx_mdio.c gd32h7xx_mdio.h gd32h7xx_mdma.c gd32h7xx_mdma.h gd32h7xx_misc.c gd32h7xx_misc.h gd32h7xx_ospi.c gd32h7xx_ospi.h gd32h7xx_ospim.c gd32h7xx_ospim.h gd32h7xx_pmu.c gd32h7xx_pmu.h gd32h7xx_rameccmu.c gd32h7xx_rameccmu.h gd32h7xx_rcu.c gd32h7xx_rcu.h gd32h7xx_rspdif.c gd32h7xx_rspdif.h gd32h7xx_rtc.c gd32h7xx_rtc.h gd32h7xx_rtdec.c gd32h7xx_rtdec.h gd32h7xx_sai.c gd32h7xx_sai.h gd32h7xx_sdio.c gd32h7xx_sdio.h gd32h7xx_spi.c gd32h7xx_spi.h gd32h7xx_syscfg.c gd32h7xx_syscfg.h gd32h7xx_timer.c gd32h7xx_timer.h gd32h7xx_tli.c gd32h7xx_tli.h gd32h7xx_tmu.c gd32h7xx_tmu.h gd32h7xx_trigsel.c gd32h7xx_trigsel.h gd32h7xx_trng.c gd32h7xx_trng.h gd32h7xx_usart.c gd32h7xx_usart.h gd32h7xx_vref.c gd32h7xx_vref.h gd32h7xx_wwdgt.c gd32h7xx_wwdgt.h
  group Startup
    ../../Startup/: startup_gd32h7xx.s
  group Utilities
    ../../Utilities/: gd32h759i_eval.c gd32h759i_eval.h
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
